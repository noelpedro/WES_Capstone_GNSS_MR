SRC_URI += "file://user_2022-01-13-07-06-00.cfg \
            file://user_2022-04-06-17-36-00.cfg \
            file://user_2022-04-06-17-43-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

